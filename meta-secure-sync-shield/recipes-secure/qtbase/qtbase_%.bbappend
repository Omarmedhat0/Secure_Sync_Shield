PACKAGECONFIG:append = " gif"
